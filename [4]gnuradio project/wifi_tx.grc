<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>20e6</value></param>
<param><key>center_freq0</key><value>2.4e9</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>200e6</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.1.24"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>otw</key><value>sc16</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
